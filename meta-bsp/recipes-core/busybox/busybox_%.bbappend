FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://busybox.cfg"